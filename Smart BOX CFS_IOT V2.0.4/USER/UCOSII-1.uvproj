# Keil uVision project UCOSII-1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UCOSII-1 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\GPIO;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\24CXX;..\HARDWARE\ADC;..\HARDWARE\ADS1115;..\HARDWARE\FLASH;..\HARDWARE\HS_BOX_CON;..\HARDWARE\HS_BOX_IOT;..\HARDWARE\MB_CRC;..\HARDWARE\DEBUG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c system_stm32f10x.c stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/GPIO/: GPIO.c
    ../HARDWARE/24CXX/: 24cxx.c myiic.c
    ../HARDWARE/ADS1115/: ads1115.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/FLASH/: flash.c spi.c
    ../HARDWARE/HS_BOX_CON/: HS_BOX_CON.c
    ../HARDWARE/HS_BOX_IOT/: HS_BOX_IOT.c
    ../HARDWARE/MB_CRC/: MB_CRC.c
    ../HARDWARE/DEBUG/: DEBUG.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_spi.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
